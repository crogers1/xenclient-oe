CXXFLAGS += "-std=gnu++98"
CFLAGS:append = " -fno-tree-vectorize"
