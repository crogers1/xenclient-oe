EXTRA_OECMAKE:append = " -DENABLE_JIT=OFF "
