# we don't use this driver; don't build it
RRECOMMENDS_${PN}_remove = "xf86-input-libinput"
RRECOMMENDS_${PN}-xwayland_remove = "xf86-input-libinput"
